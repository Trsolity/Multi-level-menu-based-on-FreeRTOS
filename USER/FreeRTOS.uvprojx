# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\KEY;.\FreeRTOS;..\HARDWARE\MPU6050\DMP;..\HARDWARE\MPU6050\IIC;..\HARDWARE\oled;..\HARDWARE\Display;..\HARDWARE\MPU6050;..\HARDWARE\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./FreeRTOS/: mytask.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/IIC/: IIC.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/Display/: display.c
    ../HARDWARE/RTC/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
